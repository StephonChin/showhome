# IAR project BT36.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\PublicFiles\Includes; PrivateFiles\Includes
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: BT36.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group PrivateIncludes
    PrivateFiles/Includes/: Attribute.h
  group PrivateSources
    PrivateFiles/Sources/: BT36.c
  group PublicIncludes
    ../PublicFiles/Includes/: CSR1010.h Key_Scan.h TypeDefine.h
  group PublicSources
    ../PublicFiles/Sources/: CSR1010.c Key_Scan.c
