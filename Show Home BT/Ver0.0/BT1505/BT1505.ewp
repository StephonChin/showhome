# IAR project BT1505.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCIncludePath2: ..\PublicFiles\Includes; PrivateFiles\Includes
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: BT1505.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
