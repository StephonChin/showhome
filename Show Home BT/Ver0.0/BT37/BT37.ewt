<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>PrivateIncludes</name>
  </group>
  <group>
    <name>PrivateSources</name>
  </group>
  <group>
    <name>PublicIncludes</name>
  </group>
  <group>
    <name>PublicSources</name>
  </group>
</project>


