# IAR project BT1505.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; APP\Include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: BT1505.s19
  ILINK.IlinkOutputFile: BT1505.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Includes
    APP/Include/: ad_scan.h data_process.h data_rcv.h data_send.h Eprom.h key_scan.h led_display.h main.h system.h timer_control.h
  group Sources
    APP/Source/: ad_scan.c data_process.c data_rcv.c data_send.c eeprom.c key_scan.c led_display.c main.c mcu_config.c timer_control.c
