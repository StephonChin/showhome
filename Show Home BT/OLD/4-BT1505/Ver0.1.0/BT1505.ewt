<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Includes</name>
    <file>
      <name>$PROJ_DIR$\APP\Include\ad_scan.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Include\data_process.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Include\data_rcv.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Include\data_send.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Include\key_scan.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Include\led_display.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Include\main.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Include\system.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Include\timer_control.h</name>
    </file>
  </group>
  <group>
    <name>Sources</name>
    <file>
      <name>$PROJ_DIR$\APP\Source\ad_scan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\data_process.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\data_rcv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\data_send.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\key_scan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\led_display.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\mcu_config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\timer_control.c</name>
    </file>
  </group>
</project>


