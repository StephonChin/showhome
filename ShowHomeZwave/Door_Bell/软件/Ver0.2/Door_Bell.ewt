<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Includes</name>
    <file>
      <name>$PROJ_DIR$\Includes\Data_Process.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Includes\Dial_Switch.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Includes\Door_Bell.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Includes\Eprom.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Includes\Key_Scan.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Includes\Led_Display.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Includes\MCU_Config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Includes\Rf_Rcv.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Includes\Speaker.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Includes\Type_Def.h</name>
    </file>
  </group>
  <group>
    <name>Sources</name>
    <file>
      <name>$PROJ_DIR$\Sources\Data_process.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\Dial_Switch.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\Door_Bell.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\Eprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\Key_Scan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\Led_Display.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\MCU_Config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\Rf_Rcv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\Speaker.c</name>
    </file>
  </group>
</project>


