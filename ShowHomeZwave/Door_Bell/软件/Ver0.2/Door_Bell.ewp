# IAR project Door_Bell.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; Includes
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Door_Bell.s19
  ILINK.IlinkOutputFile: Door_Bell.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Includes
    Includes/: Data_Process.h Dial_Switch.h Door_Bell.h Eprom.h Key_Scan.h Led_Display.h MCU_Config.h Rf_Rcv.h Speaker.h Type_Def.h
  group Sources
    Sources/: Data_process.c Dial_Switch.c Door_Bell.c Eprom.c Key_Scan.c Led_Display.c MCU_Config.c Rf_Rcv.c Speaker.c
