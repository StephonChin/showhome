# Keil uVision project ZW1105.uvproj, settings and files
target ZW1105 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ZW1105 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include
  group StartUp
    ./: STARTUP.A51
  group Sources
    ./Source/: Comm.c Data_Process.c Key_Scan.c Led_Display.c MCU_Config.c Sleep.c ZW1105.c
  group Includes
    ./Include/: Comm.h Data_Process.h Key_Scan.h Led_Display.h MCU_Config.h Sleep.h System.h ZW1105.h
