# Keil uVision project BTLED.uvproj, settings and files
target BTLED (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: BTLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\UserInc
  group StartUp
    ./: STARTUP.A51
  group SourceFiles
    ./UserSrc/: BTLED.c Data_Process.c Key_Scan.c Led_Display.c MCU_Config.c
  group IncludeFiles
    ./UserInc/: BTLED.h Data_Process.h Key_Scan.h Led_Display.h MCU_Config.h TypeDef.h
