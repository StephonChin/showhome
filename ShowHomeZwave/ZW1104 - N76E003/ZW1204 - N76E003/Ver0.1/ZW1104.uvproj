# Keil uVision project ZW1104.uvproj, settings and files
target ZW1204 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ZW1204 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include
  group Start
    ./: STARTUP.A51
  group Source
    ./Source/: Comm.c Led_Display.c MCU_Config.c Data_Process.c Sleep.c Key_Scan.c ZW1204.c
  group Include
    ./Include/: Comm.h Led_Display.h MCU_Config.h System.h Data_Process.h Sleep.h Key_Scan.h ZW1204.h
