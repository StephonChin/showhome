# Keil uVision project ZWHC-2-LED.uvproj, settings and files
target ZWHC-2-LED (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: ZWHC-2-LED_ver3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group ZWHC-2-LED
    ./: STARTUP.A51 main.c mcu_init.c mode.c led.c uart.c
